# Keil uVision project 8x8LED.uvproj, settings and files
target 8x8LED (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8x8LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: G:\danpianji\keil\C51\INC;G:\danpianji\keil\C51\INC\Atmel
  group main
    ./main/: C51S.LIB main.ASM
